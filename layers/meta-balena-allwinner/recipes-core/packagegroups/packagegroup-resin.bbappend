RDEPENDS:${PN}:append:nanopi-neo-air = " brcm-patchram-plus \
	nanopi-air-bt \
"
