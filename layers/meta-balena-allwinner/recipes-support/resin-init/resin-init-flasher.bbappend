# Flash to internal eMMC - kernel always enumerates emmc as mmcblk2
INTERNAL_DEVICE_KERNEL:nanopi-neo-air = "mmcblk2"

INTERNAL_DEVICE_KERNEL:orangepi-plus2 = "mmcblk2"

INTERNAL_DEVICE_KERNEL:ty33a-8g1g = "mmcblk2"


