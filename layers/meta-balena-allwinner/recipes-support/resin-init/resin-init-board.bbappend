
FILESEXTRAPATHS:prepend:nanopi-neo-air := "${THISDIR}/files:"

RDEPENDS:${PN}:append = " kmod"